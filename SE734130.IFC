Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SE734130.IFC
Time: 2020-04-06T09:55:51
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: SE734130
In: Default Storey
PSet_Mass_Property - Mass Measure: 43.5035; Area Measure: 1.08614 m2; Volume Measure: 0.0217517 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser vibré; MASSE: 43.5; UNIT_OF_MEASURE: - aucun -
