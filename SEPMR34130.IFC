Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SEPMR34130.IFC
Time: 2020-04-08T09:07:52
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SEPMR34130
In: Default Storey
PSet_Mass_Property - Mass Measure: 42.8749; Area Measure: 1.06773 m2; Volume Measure: 0.0214375 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser vibré; MASSE: 42.9; UNIT_OF_MEASURE: - aucun -
