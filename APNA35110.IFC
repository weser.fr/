Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APNA35110.IFC
Time: 2020-03-18T08:48:05
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: APNA35110
In: Default Storey
PSet_Mass_Property - Mass Measure: 51.3523; Area Measure: 1.03911 m2; Volume Measure: 0.0256762 m3
