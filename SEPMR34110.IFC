Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SEPMR34110.IFC
Time: 2020-04-08T09:06:06
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SEPMR34110
In: Default Storey
PSet_Mass_Property - Mass Measure: 36.2863; Area Measure: 0.910276 m2; Volume Measure: 0.0181432 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser vibré; MASSE: 36.3; UNIT_OF_MEASURE: - aucun -
