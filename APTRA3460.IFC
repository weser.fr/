Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APTRA3460.IFC
Time: 2020-03-20T13:28:08
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: APTRA3460
In: Default Storey
PSet_Mass_Property - Mass Measure: 31.1716; Area Measure: 0.566765 m2; Volume Measure: 0.0141689 m3
