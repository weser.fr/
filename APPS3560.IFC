Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APPS3560.IFC
Time: 2020-03-19T10:43:34
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: APPS3560
In: Default Storey
PSet_Mass_Property - Mass Measure: 25.8901; Area Measure: 0.537704 m2; Volume Measure: 0.012945 m3
