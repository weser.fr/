Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SETRA130.IFC
Time: 2020-04-09T08:58:15
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SETRA130
In: Default Storey
PSet_Mass_Property - Mass Measure: 41.5993; Area Measure: 1.07919 m2; Volume Measure: 0.0189088 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser coulé; MASSE: 41.6; UNIT_OF_MEASURE: - aucun -
