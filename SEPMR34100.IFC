Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SEPMR34100.IFC
Time: 2020-04-08T09:04:35
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SEPMR34100
In: Default Storey
PSet_Mass_Property - Mass Measure: 32.9921; Area Measure: 0.83155 m2; Volume Measure: 0.016496 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser vibré; MASSE: 33.0; UNIT_OF_MEASURE: - aucun -
