Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APNA3570.IFC
Time: 2020-03-18T08:43:27
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: APNA3570
In: Default Storey
PSet_Mass_Property - Mass Measure: 33.2037; Area Measure: 0.68762 m2; Volume Measure: 0.0166019 m3
