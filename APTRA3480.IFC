Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APTRA3480.IFC
Time: 2020-03-20T13:40:23
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: APTRA3480
In: Default Storey
PSet_Mass_Property - Mass Measure: 41.4452; Area Measure: 0.735302 m2; Volume Measure: 0.0188387 m3
