Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APPSS39130.IFC
Time: 2020-03-20T08:11:22
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: APPSS39130
In: Default Storey
PSet_Mass_Property - Mass Measure: 48.9362; Area Measure: 1.20626 m2; Volume Measure: 0.0244681 m3
