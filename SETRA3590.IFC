Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SETRA90.IFC
Time: 2020-04-09T08:19:44
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SETRA90
In: Default Storey
PSet_Mass_Property - Mass Measure: 28.9676; Area Measure: 0.759501 m2; Volume Measure: 0.0131671 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser coulé; MASSE: 29.0; UNIT_OF_MEASURE: - aucun -
