Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APTRA3450.IFC
Time: 2020-03-20T10:41:06
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: APTRA3450
In: Default Storey
PSet_Mass_Property - Mass Measure: 26.0348; Area Measure: 0.482496 m2; Volume Measure: 0.011834 m3
