Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APPS35130.IFC
Time: 2020-03-19T13:51:32
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: APPS35130
In: Default Storey
PSet_Mass_Property - Mass Measure: 57.5772; Area Measure: 1.15074 m2; Volume Measure: 0.0287886 m3
