Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SEPMRPS40220.IFC
Time: 2020-04-08T08:11:59
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: SEPMRPS40220
In: Default Storey
PSet_Mass_Property - Mass Measure: 89.2414; Area Measure: 2.07703 m2; Volume Measure: 0.0446207 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser vibré; MASSE: 89.2; UNIT_OF_MEASURE: - aucun -
