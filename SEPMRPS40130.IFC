Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SEPMRPS40130.IFC
Time: 2020-04-08T08:00:26
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: SEPMRPS40130
In: Default Storey
PSet_Mass_Property - Mass Measure: 51.8971; Area Measure: 1.23541 m2; Volume Measure: 0.0259486 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser vibré; MASSE: 51.9; UNIT_OF_MEASURE: - aucun -
