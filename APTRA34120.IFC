Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APTRA34120.IFC
Time: 2020-03-20T13:48:15
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: APTRA34120
In: Default Storey
PSet_Mass_Property - Mass Measure: 61.9924; Area Measure: 1.07238 m2; Volume Measure: 0.0281784 m3
