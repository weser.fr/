Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APTRA34130.IFC
Time: 2020-03-20T13:49:43
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: APTRA34130
In: Default Storey
PSet_Mass_Property - Mass Measure: 67.1292; Area Measure: 1.15664 m2; Volume Measure: 0.0305133 m3
