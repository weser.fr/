Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SETRA150.IFC
Time: 2020-04-09T09:00:46
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SETRA150
In: Default Storey
PSet_Mass_Property - Mass Measure: 47.9152; Area Measure: 1.23904 m2; Volume Measure: 0.0217796 m3
SolidWorks Custom Properties - Numéro de document: 0400-200; MATIERE: weser coulé; MASSE: 47.9; UNIT_OF_MEASURE: - aucun -
