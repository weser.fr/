Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APPSS39140.IFC
Time: 2020-03-20T08:20:45
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: APPSS39140
In: Default Storey
PSet_Mass_Property - Mass Measure: 52.712; Area Measure: 1.29845 m2; Volume Measure: 0.026356 m3
