Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: APNA3590.IFC
Time: 2020-03-18T08:49:12
Author: user
Organization: HP Inc.
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: APNA3590
In: Default Storey
PSet_Mass_Property - Mass Measure: 42.278; Area Measure: 0.863365 m2; Volume Measure: 0.021139 m3
